DESCRIPTION = "meta file for Oscam with PCSC reader support"

require conf/license/openpli-gplv2.inc

RDEPENDS:${PN} = "enigma2-plugin-softcams-oscam pcsc-lite libpcsclite1"
